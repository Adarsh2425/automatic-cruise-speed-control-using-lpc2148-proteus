# Keil uVision project ACC_DEMO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ACC_DEMO
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c uart.c uart.h delay.h LCD.c LCD.h delay.c ADC.c ADC.h Timer.c Timer.h type.h ACC_Func.c ACC_Func.h Extern_Global_Var.h Global_Var.c Common.h I2C_new.h I2C_new.c
